FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

# Kernel config is generated by defconfig + iwg20m.config
LINUX_DEFCONFIG = "shmobile_defconfig"
SRC_URI_append = " file://iwg20m.config"
