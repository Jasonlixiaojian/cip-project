DEPENDS += "cip-kernel-config"

# This config must be installed by cip-kernel-config
LINUX_DEFCONFIG = "${STAGING_DATADIR}/cip-kernel-config/${CIP_KERNEL_CONFIG}"
